# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\sys;..\HAREWARE\BEEP;..\HAREWARE\KEY;..\HAREWARE\LED;..\HAREWARE\TIMER;..\HAREWARE\Global;..\HAREWARE\USART;..\HAREWARE\DELAY;..\HAREWARE\OLED;..\HAREWARE\GEAR;..\HAREWARE\MOTOR;..\HAREWARE\USART3;..\HAREWARE\ESP8266;..\HAREWARE\DHT11;..\HAREWARE\RFID_RC522;..\HAREWARE\LCD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HAREWARE/BEEP/: beep.c
    ../HAREWARE/KEY/: key.c
    ../HAREWARE/LED/: led.c
    ../HAREWARE/TIMER/: timer.c
    ../HAREWARE/MOTOR/: motor.c
    ../HAREWARE/USART/: usart.c
    ../HAREWARE/DELAY/: delay.c
    ../HAREWARE/GEAR/: gear.c
    ../HAREWARE/USART3/: usart3.c
    ../HAREWARE/ESP8266/: common.c
    ../HAREWARE/DHT11/: dht11.c
    ../HAREWARE/RFID_RC522/: rfid_rcc522.c
    ../HAREWARE/LCD/: ILI93xx.c
